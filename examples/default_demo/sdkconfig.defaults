## examples/default_demo/sdkconfig.defaults
```kconfig
CONFIG_LWIP_IPV6=y
CONFIG_HTTPD_MAX_REQ_HDR_LEN=1024
CONFIG_MBEDTLS_SSL_IN_CONTENT_LEN=8192
```
